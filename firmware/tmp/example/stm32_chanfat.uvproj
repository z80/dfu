# Keil uVision project stm32_chanfat.uvproj, settings and files
target STM32 Flash (ARM-GNU)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_chanfat +hex
  AfterMake: proj_objdump.cmd $L@L.elf $L@L.lss
  group App Sources
    ./: startup_stm32f10x_md_mthomas.c main.c rtc.c comm.c term_io.c ff_test_term.c misc_test_term.c syscalls.c
  group App Includes
    ./: platform_config.h stm32f10x_conf.h
  group Util_Code
    ./Libraries/fat_sd/: sd_spi_stm32.c fattime.c ff.c
    ./Libraries/minIni/: minIni.c
    ./Libraries/fat_sd/option/: ccsbcs.c
    ./Libraries/EEPROMEmulation_AN/source/: eeprom.c
    ./: dcc_stdio.c
  group STM_lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_wwdg.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Other
    ./: readme.txt Makefile STM32F10x_128k_20k_flash.ld
    ./obj/: stm32_chanfat.lss
    ./lst/: stm32_chanfat.map
